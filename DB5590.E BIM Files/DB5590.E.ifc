Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-12-17T00:12:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 17 00:12:53 2024 * Host: Yogoon * Database: C:\Users\gokul\AppData\Local\Temp\ae2c5c2c-2c28-4ea3-9ab6-7e9495856a3b\8d4c4ed6-3f21-413b-a3fd-ff8132612f55\ifc * Database version: 5507 * Database creation date: Tue Dec 17 00:12:53 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 17 00:12:53 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 17 00:12:53 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: DB5590.E, DB5590.E:DB5590.E:349911
In: Level 1
Type - PredefinedType: USERDEFINED
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 145 mm; Length: 33 mm; Width: 215 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_75_50_46_31:Flush control devices; CAWS: N13/420 Proximity sensor control units_N13/300 WCs and cisterns_S90/690 Flush control devices_S90/690 Flush control devices; CodePerformance: n/a; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: AutomaticElectronic Flush Plate; DurationUnit: year; ExpectedLife: n/a; Features: TouchFree_VandalResistantLocking_CleaningMode_HygieneFlush_AdjustableSensorRange; Finish: DB5590.E.1_BrushedSatin_DB5590.E.2_Polished_DB5590.E.3_PVD_DB5590.E.5_PowderCoated_DB5590.E.6_CeramicCoated; Grade: 316; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: https://www.dolphinsolutions.co.uk/product/dolphin-electronic-infrared-anti-vandal-flush-plate/; Material: StainlessSteel; ModelNumber: DB5590.E; ModelReference: DolphinSolutionsLimited_AutomaticElectronicFlushPlate_VandalResistant; Name: FlushControlDevices_AutomaticElectronicFlushPlate_VandalResistant_DB5590.E_DolphinSolutionsLimited; NBSCode: 90-15-35/470 Flush control devices; NBSDescription: Flush control devices; NBSReference: n/a; NBSTypeID: n/a; NominalHeight: 145 mm; NominalLength: 33 mm; NominalWidth: 215 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.60.50.24; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 215 x 145 x 33 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB5590.E; Uniclass2015Code: Pr_75_50_46_31; Uniclass2015Title: Flush control devices; Uniclass2015Version: Products v1.22; Version: 3; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB5590.E
Type - Pset_SanitaryTerminalTypeBath - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_SanitaryTerminalTypeBidet - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_SanitaryTerminalTypeSanitaryFountain - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_SanitaryTerminalTypeShower - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_SanitaryTerminalTypeSink - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_SanitaryTerminalTypeWashHandBasin - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Pset_DistributionFlowElementCommon - Reference: DB5590.E:DB5590.E; sets with these values: 2
Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_AutomaticElectronicFlushPlate_VandalResistant; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: FlushControlDevices_AutomaticElectronicFlushPlate_VandalResistant_DB5590.E_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0607331 m2; Volume: 0.000302928 m3
Identity Data - Mark: 1
Other - Family: DB5590.E: DB5590.E; Family and Type: DB5590.E: DB5590.E; Type: DB5590.E: DB5590.E; Type Id: DB5590.E: DB5590.E
Phasing - Phase Created: New Construction
